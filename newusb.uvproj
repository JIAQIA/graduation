# Keil uVision project newusb.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: newusbInp +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, USE_USB_OTG_FS, STM32F4XX, MEDIA_USB_KEY, __FPU_PRESENT=0
  c include: ..\MAIN;.\discovery;.\fat\inc;.\stdlib\inc;.\usb0tglib\inc;.\usbhost\Core\inc;.\usbhost\MSC\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group
    ./: startup_stm32f4xx.s
  group user
    ./: Rwfile.c stm32f4xx_it.c system_stm32f4xx.c usb_bsp.c usbh_usr.c main.c
  group stdlib
    ./stdlib/src/: stm32f4xx_tim.c misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_gpio.c stm32f4xx_usart.c
  group usbotg
    ./usb0tglib/src/: usb_hcd_int.c usb_core.c usb_hcd.c
  group usbhost
    ./usbhost/Core/src/: usbh_stdreq.c usbh_core.c usbh_hcs.c usbh_ioreq.c
    ./usbhost/MSC/src/: usbh_msc_fatfs.c usbh_msc_scsi.c usbh_msc_bot.c usbh_msc_core.c
  group fat
    ./fat/src/: fattime.c ff.c
  group discovery
    ./discovery/: stm32f4_discovery_lis302dl.c stm32f4_discovery.c libPDMFilter_Keil.lib
  group Carve
    ./: auto_ctrl_sub.c data_deal_sub.c inter_polate_sub.c
